# Keil uVision project Puncture.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Puncture +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,_DLIB_FILE_DESCRIPTOR
  c include: ..\Document\CORE;..\Document\HARDWARE\ADC;..\Document\HARDWARE\AHRS;..\Document\HARDWARE\DS18B20;..\Document\HARDWARE\ENCODER;..\Document\HARDWARE\LED;..\Document\HARDWARE\MPU6050;..\Document\HARDWARE\RELAY;..\Document\HARDWARE\SWITCH;..\Document\STM32F10x_FWLib\inc;..\Document\STM32F10x_FWLib\src;..\Document\SYSTEM\crc16;..\Document\SYSTEM\dac;..\Document\SYSTEM\delay;..\Document\SYSTEM\iwatchdog;..\Document\SYSTEM\protocol;..\Document\SYSTEM\ringbuffer;..\Document\SYSTEM\spi;..\Document\SYSTEM\sys;..\Document\SYSTEM\time;..\Document\SYSTEM\usart;..\Document\SYSTEM\usb\CONFIG;..\Document\SYSTEM\usb\LIB;..\Document\USER;..\Document\HARDWARE\DCMOTOR
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../Document/USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../Document/CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../Document/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../Document/SYSTEM/crc16/: crc16.c
    ../Document/SYSTEM/dac/: dac.c
    ../Document/SYSTEM/delay/: delay.c
    ../Document/SYSTEM/iwatchdog/: iwatchdog.c
    ../Document/SYSTEM/protocol/: protocol.c
    ../Document/SYSTEM/ringbuffer/: ringbuffer.c
    ../Document/SYSTEM/spi/: spi.c
    ../Document/SYSTEM/sys/: config_init.c sys.c
    ../Document/SYSTEM/time/: time_user.c
    ../Document/SYSTEM/usart/: usart.c
  group HARDWARE
    ../Document/HARDWARE/ADC/: adc_dma.c
    ../Document/HARDWARE/AHRS/: ahrs_ringbuffer.c
    ../Document/HARDWARE/DS18B20/: ds18b20.c
    ../Document/HARDWARE/ENCODER/: encoder.c
    ../Document/HARDWARE/LED/: led.c
    ../Document/HARDWARE/MPU6050/: MPU6050.c
    ../Document/HARDWARE/RELAY/: relay.c
    ../Document/HARDWARE/SWITCH/: switch.c
    ../Document/HARDWARE/DCMOTOR/: dc_motor.c
  group USB
    ../Document/SYSTEM/usb/CONFIG/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usbio.c
    ../Document/SYSTEM/usb/LIB/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
